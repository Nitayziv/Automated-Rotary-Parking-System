# Keil uVision project Smpl_GPIO_StepMotor.uvproj, settings and files
target Smpl_GPIO_StepMotor (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_GPIO_StepMotor
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: Smpl_SPI_RFID.c users.c
    ../Smpl_SPI_RFID/: SPI_RC522.c
    ../Smpl_GPIO_StepMotor_5V_28BYJ-48/: Smpl_GPIO_StepMotor.c
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c ScanKey.c
    ../EXE9/: EXE9.c
    ../Smpl_UART0_SRF04/: Smpl_UART0_SRF04.c
    ../Smpl_PWM_DCservo_SG5010/: Driver_PWM_Servo.c
  group Library files
    ../../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvSPI.c DrvUART.c DrvTIMER.c
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C ScanKey.c
